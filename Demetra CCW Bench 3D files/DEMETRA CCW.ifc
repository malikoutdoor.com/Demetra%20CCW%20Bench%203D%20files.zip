Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:41:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:41:57 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{2F273850-F245-4873-9084-1080037AE66F}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:41:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:41:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:41:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA CCW:0PAAR166 - WITHOUT LEVELLING - VERDE ALPI:166659
In: 0 - Piano Terra
Type - Material: CONIFERA, VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA CCW
Type - Dati identità - BIM Name: DEMETRA CCW SENZA LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR166; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-c/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-c/
Type - Dimensioni - Dimensions: 1705 mm x r 611 mm R 1211 mm x 480 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca piccola curva modulare mod. “DEMETRA” CCW costituita da una seduta monolitica con seduta completa integrata. Copre un angolo di 90°, quindi servono 4 moduli per completare la circonferenza."; Descrizione Tecnica per Codice: PANCA DEMETRA CCW SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON BORDI SUPERIORI BOCCIARDATI VERNICIATURA ANTI-DEGRADO E SEDUTA IN LEGNO DI CONIFERA; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Small curved modular bench mod. “DEMETRA” CCW consisting of a monolithic seat with seat fully integrated. It covers a 90° angle, so 4 modules are needed to complete the circumference."; Technical Description for Article: DEMETRA CCW WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED UPPER RIMS ANTI-DECAY VARNISH AND CONIFER WOOD SEAT
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; Legno Conifera; MATERIALE SEDUTA: CONIFERA; MATERIALE SUPPORTO: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone; Coniferous wood
Type - Meccanica - Weight ( kg): 894 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA CCW: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA CCW: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA CCW: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA CCW: 0PAAR166 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 3.59447 m2; Volume: 0.379775 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
